# Keil uVision project sa_webserver_usb_msc.uvproj, settings and files
target spifi_bambino (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: sa_webserver_usbdev
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "$L@L_LPC4330_M4.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4 EXAMPLE_USB_DEVICE EXAMPLE_LWIP
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\dualcore_43xx\common;..\..\..\..\examples\dualcore_43xx\lwip\webserver\configs;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\examples\dualcore_43xx\usbd_rom\msc_ram\configs;..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom
  asm define: CORE_M4
  memory RVCT4: ROM 0x14000000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x1000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/dualcore_43xx/Blinky/: dualcore_blinky.c
    ../../../../examples/dualcore_43xx/common/: ipc_example.c ipc_msg.c m0_img_ldr.c main.c
    ../../../../examples/dualcore_43xx/lwip/webserver/: dualcore_webserver.c httpd.c lwip_fs.c
    ../../../../examples/dualcore_43xx/common/startup_code/: keil_startup_lpc43xx_m4.S
    ../../../../examples/dualcore_43xx/usbd_rom/msc_ram/: msc_desc.c msc_main.c msc_ram.c ramdisk.c
  group lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c ethernetif.c
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc18xx_43xx_systick_arch.c lpc_debug.c
  group fatfs
    ../../../../../../software/filesystems/fatfslpc/: fs_mem.c rtc.c
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../examples/dualcore_43xx/Blinky/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/keil_output/core_m4/: lib_lpc_board_bambino.lib
