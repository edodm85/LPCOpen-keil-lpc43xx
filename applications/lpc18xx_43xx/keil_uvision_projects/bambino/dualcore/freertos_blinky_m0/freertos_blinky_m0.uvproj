# Keil uVision project freertos_blinky_m0.uvproj, settings and files
target spifi_bambino (ARM-ADS)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: freertos_blinky_m0
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14040000)
  AfterMake: fromelf --bin -o "$L@L_LPC4330_M0.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0 OS_FREE_RTOS
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\dualcore_43xx\common;..\..\..\..\examples\dualcore_43xx\Blinky\configs;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0
  asm define: CORE_M0
  memory RVCT4: ROM 0x14040000 size 0x40000
  memory RVCT9: RAM 0x10080000 size 0x8000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/dualcore_43xx/blinky/: dualcore_blinky.c
    ../../../../examples/dualcore_43xx/common/: ipc_example.c ipc_msg.c main.c m0_img_ldr.c
    ../../../../examples/dualcore_43xx/common/startup_code/: keil_startup_lpc43xx_m0.S
  group freertos
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c FreeRTOS_lpc43xx_m0_Tick.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../examples/dualcore_43xx/blinky/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/keil_output/core_m0/: lib_lpc_board_bambino_m0.lib
