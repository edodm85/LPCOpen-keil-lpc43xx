# Keil uVision project sa_usbd_msc_m0.uvproj, settings and files
target spifi_bambino (ARM-ADS)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: sa_usbd_msc_m0
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "$L@L_LPC4330_M4.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0 EXAMPLE_USB_DEVICE
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\dualcore_43xx\common;..\..\..\..\examples\dualcore_43xx\usbd_rom\msc_ram\configs;..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom
  asm define: CORE_M0
  memory RVCT4: ROM 0x14040000 size 0x40000
  memory RVCT9: RAM 0x10080000 size 0x8000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/dualcore_43xx/Blinky/: dualcore_blinky.c readme.txt
    ../../../../examples/dualcore_43xx/common/: ipc_example.c ipc_msg.c m0_img_ldr.c main.c
    ../../../../examples/dualcore_43xx/usbd_rom/msc_ram/: msc_main.c msc_desc.c msc_ram.c ramdisk.c
    ../../../../examples/dualcore_43xx/common/startup_code/: keil_startup_lpc43xx_m0.S
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/keil_output/core_m0/: lib_lpc_board_bambino_m0.lib
