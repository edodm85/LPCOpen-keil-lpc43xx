# Keil uVision project usbhost_msc.uvproj, settings and files
target spifi_bambino (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: usbhost_msc
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "$L@L_LPC4330_M4.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4 __LPC43XX__ USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: CORE_M4
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../../LPCUSBlib/lpcusblib_MassStorageHost/: MassStorageHost.c readme.txt
    ../../../../startup_code/: sysinit.c
    ../../../../../../software/filesystems/fatfslpc/: fs_usb.c rtc.c
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../examples/LPCUSBlib/startup_code/: keil_startup_lpc18xx43xx.s
  group lpcusblib
    ../../../../../../software/LPCUSBLib/Drivers/USB/Class/Host/: MassStorageClassHost.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/: Host.c HostStandardReq.c USBTask.c ConfigDescriptor.c USBMemory.c USBController.c Pipe.c PipeStream.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/keil_output/core_m4/: lib_lpc_board_bambino.lib
